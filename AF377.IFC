Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: AF377.IFC
Time: 2022-01-06T03:52:00
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 324-03_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 370-02_3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 370-04_3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 370-10_3
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 377-01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 377-02
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 377-03
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: P44_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
